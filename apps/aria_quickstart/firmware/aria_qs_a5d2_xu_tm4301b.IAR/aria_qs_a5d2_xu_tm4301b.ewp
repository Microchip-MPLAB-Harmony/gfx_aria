# IAR project aria_qs_a5d2_xu_tm4301b.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\src; ..\src\config\lcdc_rgba8888_mxt_a5d2; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS; ..\..\firmware\src; ..\..\firmware\src\config\lcdc_rgba8888_mxt_a5d2; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\firmware\src; ..\..\firmware\src\config\lcdc_rgba8888_mxt_a5d2; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: aria_qs_a5d2_xu_tm4301b.out
  ILINK.IlinkIcfFile: ..\src\config\lcdc_rgba8888_mxt_a5d2\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __FPU_PRESENT=1; NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/config/lcdc_rgba8888_mxt_a5d2/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/: app.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2
    ../src/config/lcdc_rgba8888_mxt_a5d2/: device_cache.h toolchain_specifics.h definitions.h user.h configuration.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/: gfx_assets.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx/hal
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/hal/: gfx.h gfx_config.h
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/hal/inc/: gfx_color.h gfx_common.h gfx_context.h gfx_default_impl.h gfx_display.h gfx_driver_interface.h gfx_hal.h gfx_interface.h gfx_layer.h gfx_pixel_buffer.h gfx_processor_interface.h gfx_rect.h gfx_util.h gfx_draw.h gfx_draw_arc.h gfx_draw_blit.h gfx_draw_circle.h gfx_draw_ellipse.h gfx_draw_line.h gfx_draw_pixel.h gfx_draw_rect.h gfx_draw_stretchblit.h gfx_math.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx/utils
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/utils/: gfx_utils.h gfxu_config.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx/utils/inc
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/utils/inc/: gfxu_binary.h gfxu_font.h gfxu_global.h gfxu_image.h gfxu_image_utils.h gfxu_palette.h gfxu_string.h gfxu_string_utils.h gfxu_image_jpg_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx/third_party/lodepng
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/third_party/lodepng/: lodepng.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx/libaria
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/libaria/: libaria_harmony.h libaria_config.h libaria_init.h libaria.h libaria_events.h libaria_macros.h
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/libaria/inc/: libaria_array.h libaria_common.h libaria_context.h libaria_draw.h libaria_editwidget.h libaria_event.h libaria_global.h libaria_input.h libaria_layer.h libaria_math.h libaria_list.h libaria_rectarray.h libaria_scheme.h libaria_screen.h libaria_string.h libaria_utils.h libaria_widget.h libaria_widget_skin_classic_common.h libaria_widget_arc.h libaria_widget_bar_graph.h libaria_widget_button.h libaria_widget_checkbox.h libaria_widget_circle.h libaria_widget_circular_gauge.h libaria_widget_circular_slider.h libaria_widget_drawsurface.h libaria_widget_gradient.h libaria_widget_groupbox.h libaria_widget_image.h libaria_widget_imageplus.h libaria_widget_imagesequence.h libaria_widget_keypad.h libaria_widget_label.h libaria_widget_line.h libaria_widget_line_graph.h libaria_widget_list.h libaria_widget_listwheel.h libaria_widget_pie_chart.h libaria_widget_progressbar.h libaria_widget_radial_menu.h libaria_widget_radiobutton.h libaria_radiobutton_group.h libaria_widget_rectangle.h libaria_widget_scrollbar.h libaria_widget_slider.h libaria_widget_textfield.h libaria_widget_touchtest.h libaria_widget_window.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/gfx/driver/lcdc
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/driver/controller/lcdc/: drv_gfx_lcdc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/mmu
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/matrix
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/clk
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/pio
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/aic
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/tc
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/lcdc
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/lcdc/: plib_lcdc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/twihs
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/twihs/: plib_twihs_master.h plib_twihs1.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/driver
    ../src/config/lcdc_rgba8888_mxt_a5d2/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/driver/i2c
    ../src/config/lcdc_rgba8888_mxt_a5d2/driver/i2c/: drv_i2c.h drv_i2c_definitions.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/driver/input
    ../src/config/lcdc_rgba8888_mxt_a5d2/driver/input/: drv_maxtouch.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/system
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/system/time
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/system/input
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/input/: sys_input.h sys_input_gesture.h sys_input_keyboard.h sys_input_listener.h sys_input_mouse.h sys_input_touch.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/system/int
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/system/cache
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/system/debug
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_a5d2/bsp
    ../src/config/lcdc_rgba8888_mxt_a5d2/bsp/: bsp.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: device.h atsama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2
    ../src/config/lcdc_rgba8888_mxt_a5d2/: initialization.c interrupts.c cstartup.s fault_handlers.c tasks.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/: gfx_assets.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/hal
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/hal/src/: gfx.c gfx_color.c gfx_context.c gfx_default_impl.c gfx_display.c gfx_display_def.c gfx_driver_interface.c gfx_driver_def.c gfx_processor_def.c gfx_get.c gfx_interface.c gfx_layer.c gfx_pixel_buffer.c gfx_processor_interface.c gfx_rect.c gfx_util.c gfx_set.c gfx_color_blend.c gfx_color_convert.c gfx_color_lerp.c gfx_color_value.c gfx_draw_arc.c gfx_draw_blit.c gfx_draw_circle.c gfx_draw_ellipse.c gfx_draw_line.c gfx_draw_pixel.c gfx_draw_rect.c gfx_draw_stretchblit.c gfx_math.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/utils
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/utils/src/: gfxu_image.c gfxu_image_raw_external.c gfxu_image_raw_internal.c gfxu_image_rle_external.c gfxu_image_rle_internal.c gfxu_image_utils.c gfxu_palette.c gfxu_string.c gfxu_string_external.c gfxu_stringbuffer_external.c gfxu_string_internal.c gfxu_string_query.c gfxu_string_utils.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/utils/src
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/utils/src/: gfxu_image_jpg_common.c gfxu_image_jpg_internal.c gfxu_image_jpg_external.c gfxu_image_png_external.c gfxu_image_png_internal.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/third_party
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/third_party/decoder/src/: jidctint.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/third_party/lodepng
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/third_party/src/lodepng/: lodepng.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/libaria
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/libaria/: libaria_harmony.c libaria_init.c libaria_events.c libaria_macros.c
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/libaria/src/: libaria.c libaria_array.c libaria_context.c libaria_context_paint.c libaria_draw.c libaria_editwidget.c libaria_event.c libaria_input.c libaria_layer.c libaria_list.c libaria_rectarray.c libaria_scheme.c libaria_screen.c libaria_string.c libaria_utils.c libaria_widget.c libaria_widget_skin_classic.c libaria_widget_skin_classic_common.c libaria_widget_arc.c libaria_widget_arc_skin_classic.c libaria_widget_bar_graph.c libaria_widget_bar_graph_skin_classic.c libaria_widget_button.c libaria_widget_button_skin_classic.c libaria_widget_checkbox.c libaria_widget_checkbox_skin_classic.c libaria_widget_circle.c libaria_widget_circle_skin_classic.c libaria_widget_circular_gauge.c libaria_widget_circular_gauge_skin_classic.c libaria_widget_circular_slider.c libaria_widget_circular_slider_skin_classic.c libaria_widget_drawsurface.c libaria_widget_drawsurface_skin_classic.c libaria_widget_gradient.c libaria_widget_gradient_skin_classic.c libaria_widget_groupbox.c libaria_widget_groupbox_skin_classic.c libaria_widget_image.c libaria_widget_image_skin_classic.c libaria_widget_imageplus.c libaria_widget_imageplus_skin_classic.c libaria_widget_imagesequence.c libaria_widget_imagesequence_skin_classic.c libaria_widget_keypad.c libaria_widget_keypad_skin_classic.c libaria_widget_label.c libaria_widget_label_skin_classic.c libaria_widget_line.c libaria_widget_line_skin_classic.c libaria_widget_line_graph.c libaria_widget_line_graph_skin_classic.c libaria_widget_list.c libaria_widget_list_skin_classic.c libaria_widget_listwheel.c libaria_widget_listwheel_skin_classic.c libaria_widget_pie_chart.c libaria_widget_pie_chart_skin_classic.c libaria_widget_progressbar.c libaria_widget_progressbar_skin_classic.c libaria_widget_radial_menu.c libaria_widget_radial_menu_skin_classic.c libaria_widget_radiobutton.c libaria_widget_radiobutton_skin_classic.c libaria_radiobutton_group.c libaria_widget_rectangle.c libaria_widget_rectangle_skin_classic.c libaria_widget_scrollbar.c libaria_widget_scrollbar_skin_classic.c libaria_widget_slider.c libaria_widget_slider_skin_classic.c libaria_widget_textfield.c libaria_widget_textfield_skin_classic.c libaria_widget_touchtest.c libaria_widget_touchtest_skin_classic.c libaria_widget_window.c libaria_widget_window_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/gfx/driver/lcdc
    ../src/config/lcdc_rgba8888_mxt_a5d2/gfx/driver/controller/lcdc/: drv_gfx_lcdc.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/stdio
    ../src/config/lcdc_rgba8888_mxt_a5d2/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/mmu
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/matrix
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/clk
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/pio
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/aic
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/tc
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/lcdc
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/lcdc/: plib_lcdc.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/peripheral/twihs
    ../src/config/lcdc_rgba8888_mxt_a5d2/peripheral/twihs/: plib_twihs1.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/driver/i2c
    ../src/config/lcdc_rgba8888_mxt_a5d2/driver/i2c/src/: drv_i2c.c drv_i2c_local.h
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/driver/input
    ../src/config/lcdc_rgba8888_mxt_a5d2/driver/input/: drv_maxtouch.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/system/time
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/system/input
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/input/: sys_input.c sys_input_listener.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/system/int
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/system/cache
    ../src/config/lcdc_rgba8888_mxt_a5d2/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_a5d2/bsp
    ../src/config/lcdc_rgba8888_mxt_a5d2/bsp/: bsp.c
  group Harmony3/Linker File
    ../src/config/lcdc_rgba8888_mxt_a5d2/: ddr.icf
