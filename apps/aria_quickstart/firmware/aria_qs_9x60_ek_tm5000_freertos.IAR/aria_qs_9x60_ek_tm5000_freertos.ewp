# IAR project aria_qs_9x60_ek_tm5000_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\lcdc_rgba8888_mxt_9x60_freertos_wvga; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\src\third_party\rtos\FreeRTOS\Source\include; .; ..\..\firmware\src; ..\..\firmware\src\config\lcdc_rgba8888_mxt_9x60_freertos_wvga; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\firmware\src; ..\..\firmware\src\config\lcdc_rgba8888_mxt_9x60_freertos_wvga; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\ARM926; ..\..\firmware\src\third_party\rtos\FreeRTOS\Source\Include
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: aria_qs_9x60_ek_tm5000_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\lcdc_rgba8888_mxt_9x60_freertos_wvga\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/osal/: osal.h osal_definitions.h osal_freertos.h
    ../src/: app.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/: device_cache.h toolchain_specifics.h definitions.h FreeRTOSConfig.h user.h configuration.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/: gfx_assets.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/hal
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/hal/: gfx.h gfx_config.h
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/hal/inc/: gfx_color.h gfx_common.h gfx_context.h gfx_default_impl.h gfx_display.h gfx_driver_interface.h gfx_hal.h gfx_interface.h gfx_layer.h gfx_pixel_buffer.h gfx_processor_interface.h gfx_rect.h gfx_util.h gfx_draw.h gfx_draw_arc.h gfx_draw_blit.h gfx_draw_circle.h gfx_draw_ellipse.h gfx_draw_line.h gfx_draw_pixel.h gfx_draw_rect.h gfx_draw_stretchblit.h gfx_math.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/processor/gfx2d/: drv_gfx2d.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/controller/lcdc/: drv_gfx_lcdc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils/: gfx_utils.h gfxu_config.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils/inc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils/inc/: gfxu_binary.h gfxu_font.h gfxu_global.h gfxu_image.h gfxu_image_utils.h gfxu_palette.h gfxu_string.h gfxu_string_utils.h gfxu_image_jpg_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/third_party/lodepng
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/third_party/lodepng/: lodepng.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/libaria
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/libaria/: libaria_rtos.h libaria_harmony.h libaria_config.h libaria_init.h libaria.h libaria_events.h libaria_macros.h
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/libaria/inc/: libaria_context_rtos.h libaria_event_rtos.h libaria_input_rtos.h libaria_array.h libaria_common.h libaria_context.h libaria_draw.h libaria_editwidget.h libaria_event.h libaria_global.h libaria_input.h libaria_layer.h libaria_math.h libaria_list.h libaria_rectarray.h libaria_scheme.h libaria_screen.h libaria_string.h libaria_utils.h libaria_widget.h libaria_widget_skin_classic_common.h libaria_widget_arc.h libaria_widget_bar_graph.h libaria_widget_button.h libaria_widget_checkbox.h libaria_widget_circle.h libaria_widget_circular_gauge.h libaria_widget_circular_slider.h libaria_widget_drawsurface.h libaria_widget_gradient.h libaria_widget_groupbox.h libaria_widget_image.h libaria_widget_imageplus.h libaria_widget_imagesequence.h libaria_widget_keypad.h libaria_widget_label.h libaria_widget_line.h libaria_widget_line_graph.h libaria_widget_list.h libaria_widget_listwheel.h libaria_widget_pie_chart.h libaria_widget_progressbar.h libaria_widget_radial_menu.h libaria_widget_radiobutton.h libaria_radiobutton_group.h libaria_widget_rectangle.h libaria_widget_scrollbar.h libaria_widget_slider.h libaria_widget_textfield.h libaria_widget_touchtest.h libaria_widget_window.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/bsp
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/bsp/: bsp.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pit
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/mmu
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/clk
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pio
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/aic
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/tc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/flexcom/twi
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/flexcom/twi/: plib_flexcom0_twi.h plib_flexcom_twi_master.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/lcdc/: plib_lcdc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/gfx2d/: plib_gfx2d.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/i2c
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/i2c/: drv_i2c.h drv_i2c_definitions.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/input
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/input/: drv_maxtouch.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/time
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/input
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/input/: sys_input.h sys_input_gesture.h sys_input_keyboard.h sys_input_listener.h sys_input_mouse.h sys_input_touch.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/int
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/cache
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/debug
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/debug/: sys_debug.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: device.h sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h stream_buffer.h message_buffer.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: portmacro.h
  group Harmony3/Source Files
    ../src/: main.c app.c
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/osal/: osal_freertos.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/: initialization.c interrupts.c cstartup.s vectortrap.s freertos_hooks.c tasks.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/: gfx_assets.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/hal
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/hal/src/: gfx.c gfx_color.c gfx_context.c gfx_default_impl.c gfx_display.c gfx_display_def.c gfx_driver_interface.c gfx_driver_def.c gfx_processor_def.c gfx_get.c gfx_interface.c gfx_layer.c gfx_pixel_buffer.c gfx_processor_interface.c gfx_rect.c gfx_util.c gfx_set.c gfx_color_blend.c gfx_color_convert.c gfx_color_lerp.c gfx_color_value.c gfx_draw_arc.c gfx_draw_blit.c gfx_draw_circle.c gfx_draw_ellipse.c gfx_draw_line.c gfx_draw_pixel.c gfx_draw_rect.c gfx_draw_stretchblit.c gfx_math.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/processor/gfx2d/: drv_gfx2d_hal.c drv_gfx2d.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/driver/controller/lcdc/: drv_gfx_lcdc.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils/src/: gfxu_image.c gfxu_image_raw_external.c gfxu_image_raw_internal.c gfxu_image_rle_external.c gfxu_image_rle_internal.c gfxu_image_utils.c gfxu_palette.c gfxu_string.c gfxu_string_external.c gfxu_stringbuffer_external.c gfxu_string_internal.c gfxu_string_query.c gfxu_string_utils.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils/src
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/utils/src/: gfxu_image_jpg_common.c gfxu_image_jpg_internal.c gfxu_image_jpg_external.c gfxu_image_png_external.c gfxu_image_png_internal.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/third_party
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/third_party/decoder/src/: jidctint.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/third_party/lodepng
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/third_party/src/lodepng/: lodepng.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/libaria
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/libaria/: libaria_rtos.c libaria_context_rtos.c libaria_event_rtos.c libaria_input_rtos.c libaria_harmony.c libaria_init.c libaria_events.c libaria_macros.c
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/gfx/libaria/src/: libaria.c libaria_array.c libaria_context.c libaria_context_paint.c libaria_draw.c libaria_editwidget.c libaria_event.c libaria_input.c libaria_layer.c libaria_list.c libaria_rectarray.c libaria_scheme.c libaria_screen.c libaria_string.c libaria_utils.c libaria_widget.c libaria_widget_skin_classic.c libaria_widget_skin_classic_common.c libaria_widget_arc.c libaria_widget_arc_skin_classic.c libaria_widget_bar_graph.c libaria_widget_bar_graph_skin_classic.c libaria_widget_button.c libaria_widget_button_skin_classic.c libaria_widget_checkbox.c libaria_widget_checkbox_skin_classic.c libaria_widget_circle.c libaria_widget_circle_skin_classic.c libaria_widget_circular_gauge.c libaria_widget_circular_gauge_skin_classic.c libaria_widget_circular_slider.c libaria_widget_circular_slider_skin_classic.c libaria_widget_drawsurface.c libaria_widget_drawsurface_skin_classic.c libaria_widget_gradient.c libaria_widget_gradient_skin_classic.c libaria_widget_groupbox.c libaria_widget_groupbox_skin_classic.c libaria_widget_image.c libaria_widget_image_skin_classic.c libaria_widget_imageplus.c libaria_widget_imageplus_skin_classic.c libaria_widget_imagesequence.c libaria_widget_imagesequence_skin_classic.c libaria_widget_keypad.c libaria_widget_keypad_skin_classic.c libaria_widget_label.c libaria_widget_label_skin_classic.c libaria_widget_line.c libaria_widget_line_skin_classic.c libaria_widget_line_graph.c libaria_widget_line_graph_skin_classic.c libaria_widget_list.c libaria_widget_list_skin_classic.c libaria_widget_listwheel.c libaria_widget_listwheel_skin_classic.c libaria_widget_pie_chart.c libaria_widget_pie_chart_skin_classic.c libaria_widget_progressbar.c libaria_widget_progressbar_skin_classic.c libaria_widget_radial_menu.c libaria_widget_radial_menu_skin_classic.c libaria_widget_radiobutton.c libaria_widget_radiobutton_skin_classic.c libaria_radiobutton_group.c libaria_widget_rectangle.c libaria_widget_rectangle_skin_classic.c libaria_widget_scrollbar.c libaria_widget_scrollbar_skin_classic.c libaria_widget_slider.c libaria_widget_slider_skin_classic.c libaria_widget_textfield.c libaria_widget_textfield_skin_classic.c libaria_widget_touchtest.c libaria_widget_touchtest_skin_classic.c libaria_widget_window.c libaria_widget_window_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/bsp
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/bsp/: bsp.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pit
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/mmu
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/clk
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pio
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/aic
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/tc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/flexcom/twi
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/flexcom/twi/: plib_flexcom0_twi.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/lcdc/: plib_lcdc.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/peripheral/gfx2d/: plib_gfx2d.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/stdio
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/i2c
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/i2c/src/: drv_i2c.c drv_i2c_local.h
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/input
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/driver/input/: drv_maxtouch.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/time
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/input
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/input/: sys_input.c sys_input_listener.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/int
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/cache
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/system/cache/: sys_cache.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/ARM926
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/ARM926/: port.c portASM.s FreeRTOS_tick_config.c
  group Harmony3/Linker File
    ../src/config/lcdc_rgba8888_mxt_9x60_freertos_wvga/: ddram.icf
